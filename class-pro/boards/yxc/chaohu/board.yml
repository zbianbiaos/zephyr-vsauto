## class-pro/boards/yxc/chaohu/board.yml
```yaml
board:
  name: chaohu
  full_name: Class Boards
  vendor: yxc
  socs:
    - name: stm32f407xx
```
